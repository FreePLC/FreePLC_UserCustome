# IAR project FreePLC_UserCustom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV44F256xxx16 NXP MKV44F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167,Pa182
  ICCARM.CCIncludePath2: CMSIS; board; drivers; source; startup; utilities; rts; protocol\modbusRTU; protocol\Ethernet\APP; protocol\Ethernet\W5100S
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: CMSIS; board; drivers; source; startup; utilities
  OBJCOPY.OOCOutputFile: FreePLC_UserCustom.srec
  ILINK.IlinkOutputFile: FreePLC_UserCustom.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  group (top)
    ./: MKV46F256xxx16_flash.icf
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm4.h fsl_device_registers.h MKV46F16.h MKV46F16_features.h mpu_armv7.h system_MKV46F16.c system_MKV46F16.h
  group drivers
    drivers/: fsl_cadc.c fsl_cadc.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_pit.c fsl_pit.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group protocol/ModbusRTU
    protocol/modbusRTU/: Modbus.c Modbus.h Modbus_Porting.c Modbus_Porting.h ModbusMasterApp.c ModbusMasterApp.h ModbusSlaveApp.c ModbusSlaveApp.h
  group protocol/Network_W5100s/APP
    protocol/Ethernet/APP/: dhcp.c dhcp.h udp.c udp.h
  group protocol/Network_W5100s/W5100s
    protocol/Ethernet/W5100S/: socket.c socket.h types.h utility.c utility.h w5100s.c w5100s.h w5100s_conf.c w5100s_conf.h W5100s_Porting.c W5100s_Porting.h wizchip_conf.c wizchip_conf.h
  group rts
    rts/: Plc_abi.h plc_driver.c Plc_driver.h plc_flash.c Plc_flash.h plc_main.c plc_rte.c
  group source
    source/: main.c Plc_userCode.c Plc_userCode.h
  group startup
    startup/: startup_MKV46F16.s
