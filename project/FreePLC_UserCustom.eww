<?xml version="1.0" encoding="ISO-8859-1" standalone="no"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>FreePLC_UserCustom</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>FreePLC_UserCustom</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>FreePLC_UserCustom</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>FreePLC_UserCustom</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/FreePLC_UserCustom.ewp</path>
  </project>
</workspace>
